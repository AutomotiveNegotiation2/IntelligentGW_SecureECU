
IMAGE_INSTALL += "protobuf-c-dev protobuf-dev"
